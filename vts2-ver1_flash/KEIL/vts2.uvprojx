# Keil uVision project vts2.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: NUC200SE3AN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: vts2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RXBUFSIZE=700 TXBUFSIZE=1500
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c Thread.c Timer.c WinboundFlash.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, Device:Driver:ADC 3.00.002, Device:Driver:CLK 3.00.002, Device:Driver:GPIO 3.00.002, Device:Driver:I2C 3.00.002, Device:Driver:SPI 3.00.002, Device:Driver:SYS 3.00.002, Device:Driver:Timer 3.00.002, Device:Driver:UART 3.00.002, Device:Driver:WWDT 3.00.002, Device:Startup 3.00.002
