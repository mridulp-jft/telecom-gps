# Keil uVision project PersonalTracker_BT3.0_MC60_Nano110LE3BN.uvprojx, settings and files
target PersonalTracker_MC60_Nano110LE3BN (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NANO110RE3BN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RXBUFSIZE=1000 TXBUFSIZE=3000
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Nano100Series\Include;..\..\Library\StdDriver\inc;..\..\Library\Device\Nuvoton\Nano100Series\Source
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group User
    ./: Thread.c Timer.c main.c
  group Libraries
    ../../Library/StdDriver/src/: sys.c clk.c gpio.c uart.c retarget.c adc.c wdt.c wwdt.c i2c.c
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0
