# Keil uVision project UART_TxRx_Function.uvprojx, settings and files
target UART_TxRx_Function (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC200SE3AN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: UART_TxRx_Function
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RXBUFSIZE=700 TXBUFSIZE=3500
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC200Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC200Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group User
    ./: main.c Thread.c Timer.c
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0, Device:Driver:ADC 3.00.002, Device:Driver:CLK 3.00.002, Device:Driver:GPIO 3.00.002, Device:Driver:I2C 3.00.002, Device:Driver:SYS 3.00.002, Device:Driver:UART 3.00.002, Device:Driver:WWDT 3.00.002, Device:Startup 3.00.002
