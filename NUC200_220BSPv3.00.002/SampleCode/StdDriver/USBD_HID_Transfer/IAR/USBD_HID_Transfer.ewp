# IAR project USBD_HID_Transfer.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC200AN series Nuvoton NUC200AN series (NUC200AN,NUC220AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC200Series\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_HID_Transfer.bin
  ILINK.IlinkOutputFile: USBD_HID_Transfer.out
  ILINK.IlinkIcfFile: USBD_HID_Transfer.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC200Series/Source/IAR/: startup_NUC200Series.s
    ../../../../Library/Device/Nuvoton/NUC200Series/Source/: system_NUC200Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c usbd.c
  group User
    ../: descriptors.c hid_transfer.c main.c
