# IAR project GPIO_EINTAndDebounce.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC200AN series Nuvoton NUC200AN series (NUC200AN,NUC220AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC200Series\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO_EINTAndDebounce.bin
  ILINK.IlinkOutputFile: GPIO_EINTAndDebounce.out
  ILINK.IlinkIcfFile: GPIO_EINTAndDebounce.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC200Series/Source/IAR/: startup_NUC200Series.s
    ../../../../Library/Device/Nuvoton/NUC200Series/Source/: system_NUC200Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c
