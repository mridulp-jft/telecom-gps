# IAR project PWM_DoubleBuffer.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC200AN series Nuvoton NUC200AN series (NUC200AN,NUC220AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC200Series\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWM_DoubleBuffer.bin
  ILINK.IlinkOutputFile: PWM_DoubleBuffer.out
  ILINK.IlinkIcfFile: NUC200Series.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC200Series/Source/IAR/: startup_NUC200Series.s
    ../../../../Library/Device/Nuvoton/NUC200Series/Source/: system_NUC200Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c pwm.c retarget.c sys.c uart.c
  group User
    ../: main.c
