# Keil uVision project KEIL_MAG.uvprojx, settings and files
target KL26Z128 - Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL26Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.11.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: KEIL_MAG_Flash +hex
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe --m32combined --output=.\UV4Build\@L.srec !L
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe --m32combined --output=.\UV4Build\@L.bin !L
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: KEIL FREEDOM CMSIS
  c include: ..\..\..\src\projects\KEIL_MAG;..\..\..\src\common;..\..\..\src\cpu;..\..\..\src\cpu\headers\CMSIS\MKL26Z4\Include;..\..\..\src\drivers\llwu;..\..\..\src\drivers\lptmr;..\..\..\src\drivers\mcg;..\..\..\src\drivers\pmc;..\..\..\src\drivers\rcm;..\..\..\src\drivers\rtc;..\..\..\src\drivers\smc;..\..\..\src\drivers\uart;..\..\..\src\drivers\cmp;..\..\..\src\platforms;..\..;..\..\..\src\cpu\CMSIS\Source;..\..\..\src\cpu\CMSIS\Source\arm;..\..\..\..\inc;..\vts_ver3_rev1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group project
    ../../../src/projects/KEIL_MAG/: vts_ver2.c
    ../../../src/common/: asin.c median.c sqrt16.c
  group common
    ../../../src/common/: uif.c alloc.c assert.c io.c memtest.c queue.c stdlib.c common.h
  group cpu
    ../../../src/cpu/: nmi_isr_handler.c start.c sysinit.c
    ../../../src/cpu/CMSIS/Source/: system_MKL26Z4.c
    ../../../src/cpu/CMSIS/Source/arm/: startup_MKL26Z4.s
  group drivers
    ../../../src/drivers/cmp/: cmp.c
    ../../../src/drivers/llwu/: llwu.c
    ../../../src/drivers/lptmr/: lptmr.c
    ../../../src/drivers/mcg/: mcg.c
    ../../../src/drivers/pmc/: pmc.c
    ../../../src/drivers/rcm/: rcm.c
    ../../../src/drivers/rtc/: rtc.c
    ../../../src/drivers/smc/: smc.c
    ../../../src/drivers/uart/: uart.c Serial.c Retarget.c
  group platforms
    ../../../src/platforms/: tower.h freedom.h
    ../../../src/cpu/headers/CMSIS/MKL26Z4/Include/: MKL26Z4.h MemMapPtr_KL26Z4.h
software components: CMSIS:CORE 4.3.0
