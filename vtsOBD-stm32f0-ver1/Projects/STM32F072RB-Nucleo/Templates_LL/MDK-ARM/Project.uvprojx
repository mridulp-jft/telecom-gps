# Keil uVision project Project.uvprojx, settings and files
target STM32F072RB-Nucleo (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072RB-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F072xB,USE_STM32F0XX_NUCLEO,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../Drivers/STM32F0xx_HAL_Driver/Inc
  library: MicroLIB
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_LL_Driver
    ../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_spi.c stm32f0xx_ll_exti.c stm32f0xx_ll_rcc.c stm32f0xx_ll_rtc.c stm32f0xx_ll_dac.c stm32f0xx_ll_crs.c stm32f0xx_ll_comp.c stm32f0xx_ll_pwr.c stm32f0xx_ll_crc.c stm32f0xx_ll_tim.c stm32f0xx_ll_utils.c stm32f0xx_ll_usart.c stm32f0xx_ll_i2c.c stm32f0xx_ll_gpio.c stm32f0xx_ll_dma.c stm32f0xx_ll_adc.c
  group Example/MDK-ARM
    ./: startup_stm32f072xb.s
  group Example/User
    ../Src/: stm32f0xx_it.c main.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
