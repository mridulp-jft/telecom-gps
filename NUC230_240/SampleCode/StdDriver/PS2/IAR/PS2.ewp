# IAR project PS2.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC200AE series Nuvoton NUC200AE series (NUC230AE,NUC240AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PS2.bin
  ILINK.IlinkOutputFile: PS2.out
  ILINK.IlinkIcfFile: PS2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/IAR/: startup_NUC230_240.s
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c ps2.c retarget.c sys.c uart.c
  group User
    ../: main.c
