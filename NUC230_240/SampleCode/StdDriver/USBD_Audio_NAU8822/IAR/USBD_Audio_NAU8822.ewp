# IAR project USBD_Audio_NAU8822.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC200AE series Nuvoton NUC200AE series (NUC230AE,NUC240AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_Audio_NAU8822.bin
  ILINK.IlinkOutputFile: USBD_Audio_NAU8822.out
  ILINK.IlinkIcfFile: USBD_Audio_NAU8822.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/IAR/: startup_NUC230_240.s
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c i2c.c i2s.c retarget.c sys.c timer.c usbd.c
  group User
    ../: descriptors.c main.c usbd_audio.c
