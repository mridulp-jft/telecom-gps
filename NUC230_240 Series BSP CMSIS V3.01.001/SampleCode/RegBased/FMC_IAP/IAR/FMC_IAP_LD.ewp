# IAR project FMC_IAP_LD.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC200AE series Nuvoton NUC200AE series (NUC230AE,NUC240AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: LDROM=1
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_IAP_LD.bin
  ILINK.IlinkOutputFile: FMC_IAP_LD.out
  ILINK.IlinkIcfFile: FMC_IAP_LD.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/IAR/: startup_NUC230_240.s
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main_LD.c
