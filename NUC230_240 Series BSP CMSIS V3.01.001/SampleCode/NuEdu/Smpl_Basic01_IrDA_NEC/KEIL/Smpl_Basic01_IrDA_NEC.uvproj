# Keil uVision project Smpl_Basic01_IrDA_NEC.uvproj, settings and files
target Smpl_Basic01_IrDA_NEC (ARM-ADS)
  device: NUC240VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Smpl_Basic01_LED
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\NuEdu\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c gpio.c pwm.c adc.c uart.c
  group NuEdu
    ../../../../Library/NuEdu/src/: NuEdu-Basic01_LED.c NuEdu-Basic01_System.c NuEdu-Basic01_IrDA_NEC.c NuEdu-Basic01_UART.c NuEdu-Basic01_PWM_Capture.c NuEdu-Basic01_Button.c
