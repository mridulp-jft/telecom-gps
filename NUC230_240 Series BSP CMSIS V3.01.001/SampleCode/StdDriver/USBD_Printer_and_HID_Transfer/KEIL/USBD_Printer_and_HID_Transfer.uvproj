# Keil uVision project USBD_Printer_and_HID_Transfer.uvproj, settings and files
target USBD_Printer_and_HID_Transfer (ARM-ADS)
  device: NUC240VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USBD_Printer_and_HID_Transfer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group User
    ../: descriptors.c micro_printer_and_hid_transfer.c main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c usbd.c sys.c clk.c
