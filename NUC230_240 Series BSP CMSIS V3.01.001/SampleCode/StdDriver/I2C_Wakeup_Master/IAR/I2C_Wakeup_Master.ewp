# IAR project I2C_Wakeup_Master.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC200AE series Nuvoton NUC200AE series (NUC230AE,NUC240AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_Wakeup_Master.bin
  ILINK.IlinkOutputFile: I2C_Wakeup_Master.out
  ILINK.IlinkIcfFile: I2C_Wakeup_Master.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/IAR/: startup_NUC230_240.s
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c retarget.c sys.c uart.c
  group User
    ../: main.c
